# Keil uVision project task2.uvproj, settings and files
target M480_LCD_with_Touch (6220000::V6.22::ARMCLANG)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: M480_LCD_with_Touch
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=3
  c include: .\Library\CMSIS\Include;.\Library\StdDriver\inc;.\Library\Device\Nuvoton\M480\Include;..\KEIL;..\..\Tutorial_8_M480_LCD_with_Touch;.\Library;..\..\task2-complete
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/M480/Source/: system_M480.c
    ./Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c EBI_LCD_Module.c image.c image_16x32.c EBI_LCD_Module.h
    ./: sys_init.h sys_init.c game_draw.h game_draw.c tetris_draw.h tetris_draw.c spawn_block.c spawn_block.h rotation.c rotation.h playfield.c playfield.h
  group Library
    ./Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c gpio.c eadc.c ebi.c
